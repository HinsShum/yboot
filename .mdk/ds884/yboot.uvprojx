# Keil uVision project yboot.uvprojx, settings and files
target Release (6150000::V6.15::ARMCLANG)
  device: GD32E230G8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: yboot +hex
  AfterMake: fromelf --bin output/*.axf --output bin/yboot.bin
  AfterMake: cmd.exe /c copy /y output\*.hex bin\yboot.hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E23X, GD32E230, CONFIG_OPTIONS_FILE=<config/ds884/options.h>, YMODEM_CONFIG_FILE=<config/ds884/ymodem_config.h>, NDEBUG
  c include: ..\..\arch\gd32e23x\include;..\..\arch\gd32e23x\ds884\include;..\..\bsp\ds884\include;..\..\common\include;..\..\components\ymodem\src\inc;..\..\driver\include;..\..\lib\GigaDevice\gd32e23x\peripheral\Include;..\..\src\include;..\..\utils\include;..\..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\..\config\ds884\arm\ds884_yboot.sct
  group arch
    ../../arch/gd32e23x/: system_gd32e23x.c
    ../../arch/gd32e23x/ds884/: cpu.c gd32e23x_it.c
    ../../arch/gd32e23x/ds884/arm/: startup_gd32e23x.s
  group bsp
    ../../bsp/ds884/: bsp_com.c bsp_flash1.c bsp_flash2.c bsp_wdt.c
  group driver
    ../../driver/: device.c driver.c flash.c serial.c wdt.c
  group lib
    ../../lib/GigaDevice/gd32e23x/peripheral/Source/: gd32e23x_dbg.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_misc.c gd32e23x_rcu.c gd32e23x_syscfg.c gd32e23x_usart.c
  group common
    ../../common/: simplefifo.c
  group components
    ../../components/ymodem/src/: ymodem.c ymodem_crc.c
  group src
    ../../src/: download.c firmware.c irq_process.c platform.c strategy.c
    ../../src/ds884/: fputc.c main.c
  group utils
    ../../utils/: checksum.c md5.c utils.c
