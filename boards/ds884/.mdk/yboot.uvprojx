# Keil uVision project yboot.uvprojx, settings and files
target Release (6140000::V6.14::ARMCLANG)
  device: GD32E230G8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: yboot +hex
  AfterMake: fromelf --bin #L --output bin/@L.bin
  AfterMake: cmd.exe /c copy /y $L\@L*.hex bin\@L.hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E23X, GD32E230, CONFIG_OPTIONS_FILE=<config/options.h>, YMODEM_CONFIG_FILE=<config/ymodem_config.h>, NDEBUG
  c include: ..\..\..\arch\gd32e23x\inc;..\..\..\common\inc;..\..\..\components\ymodem\src\inc;..\..\..\driver\include;..\..\..\lib\GigaDevice\gd32e23x\peripheral\Include;..\..\..\utils\include;..\..\..\inc;..\..\inc;..\bsp\inc;..\cpu\inc;..\..\ds884
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\config\arm\ds884_yboot.sct
  group cpu
    ../../../arch/gd32e23x/: system_gd32e23x.c
    ../cpu/: cpu.c gd32e23x_it.c
    ../cpu/arm/: startup_gd32e23x.s
  group bsp
    ../bsp/: bsp_com.c bsp_flash1.c bsp_flash2.c bsp_wdt.c
  group driver
    ../../../driver/: device.c driver.c flash.c serial.c wdt.c
  group lib
    ../../../lib/GigaDevice/gd32e23x/peripheral/Source/: gd32e23x_dbg.c gd32e23x_fmc.c gd32e23x_gpio.c gd32e23x_fwdgt.c gd32e23x_misc.c gd32e23x_rcu.c gd32e23x_syscfg.c gd32e23x_usart.c
  group common
    ../../../common/: simplefifo.c
  group components
    ../../../components/ymodem/src/: ymodem.c ymodem_crc.c
  group src
    ../../: download.c firmware.c irq_process.c platform.c strategy.c
    ../src/: fputc.c main.c
  group utils
    ../../../utils/: checksum.c md5.c utils.c
